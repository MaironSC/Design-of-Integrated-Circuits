CIRCUIT C:\Users\MaironSC\Desktop\CCI TRAB 2\Circuito Completo\CIRCUITO COMPLETO - MICROWIND\F1eF2eF3.MSK
*
* IC Technology: K-CMOS Free-PDK-Based 45nm - 6 Metal
*
VDD 1 0 DC 1.00
VC 29 0 DC 0 PULSE(0.00 1.00 3.00N 0.02N 0.03N 3.98N 7.03N)
VD 30 0 DC 0 PULSE(0.00 1.00 8.00N 0.03N 0.02N 7.98N 16.02N)
VB 32 0 DC 0 PULSE(0.00 1.00 4.00N 0.03N 0.03N 1.97N 6.03N)
VA 34 0 DC 0 PULSE(0.00 1.00 2.00N 0.02N 0.02N 0.98N 3.02N)
*
* List of nodes
* "out" corresponds to n°4
* "N5" corresponds to n°5
* "N6" corresponds to n°6
* "N7" corresponds to n°7
* "N8" corresponds to n°8
* "F2" corresponds to n°9
* "F1" corresponds to n°14
* "not C" corresponds to n°17
* "not B" corresponds to n°19
* "not A" corresponds to n°20
* "GND" corresponds to n°21
* "C" corresponds to n°29
* "D" corresponds to n°30
* "B" corresponds to n°32
* "A" corresponds to n°34
*
* MOS devices
MN1 0 5 4 0 N1  W= 0.10U L= 0.05U
MN2 0 14 5 0 N1  W= 0.20U L= 0.05U
MN3 5 9 0 0 N1  W= 0.20U L= 0.05U
MN4 22 29 9 0 N1  W= 0.40U L= 0.05U
MN5 23 20 22 0 N1  W= 0.40U L= 0.05U
MN6 22 19 23 0 N1  W= 0.40U L= 0.05U
MN7 24 17 22 0 N1  W= 0.40U L= 0.05U
MN8 22 20 24 0 N1  W= 0.40U L= 0.05U
MN9 24 32 22 0 N1  W= 0.40U L= 0.05U
MN10 25 34 24 0 N1  W= 0.40U L= 0.05U
MN11 24 19 25 0 N1  W= 0.40U L= 0.05U
MN12 25 17 24 0 N1  W= 0.40U L= 0.05U
MN13 0 18 14 0 N1  W= 0.10U L= 0.05U
MN14 0 29 25 0 N1  W= 0.40U L= 0.05U
MN15 25 32 0 0 N1  W= 0.40U L= 0.05U
MN16 0 34 25 0 N1  W= 0.40U L= 0.05U
MN17 26 30 18 0 N1  W= 0.40U L= 0.05U
MN18 0 29 17 0 N1  W= 0.10U L= 0.05U
MN19 27 29 26 0 N1  W= 0.40U L= 0.05U
MN20 0 32 19 0 N1  W= 0.13U L= 0.05U
MN21 28 32 27 0 N1  W= 0.40U L= 0.05U
MN22 0 34 20 0 N1  W= 0.10U L= 0.05U
MN23 0 34 28 0 N1  W= 0.40U L= 0.05U
MP1 1 5 4 1 P1  W= 0.10U L= 0.05U
MP2 6 14 5 1 P1  W= 0.28U L= 0.05U
MP3 1 9 6 1 P1  W= 0.28U L= 0.05U
MP4 7 29 1 1 P1  W= 0.45U L= 0.05U
MP5 8 20 7 1 P1  W= 0.45U L= 0.05U
MP6 9 19 8 1 P1  W= 0.45U L= 0.05U
MP7 10 17 9 1 P1  W= 0.45U L= 0.05U
MP8 11 20 10 1 P1  W= 0.45U L= 0.05U
MP9 1 32 11 1 P1  W= 0.45U L= 0.05U
MP10 12 34 1 1 P1  W= 0.45U L= 0.05U
MP11 13 19 12 1 P1  W= 0.45U L= 0.05U
MP12 9 17 13 1 P1  W= 0.45U L= 0.05U
MP13 1 18 14 1 P1  W= 0.10U L= 0.05U
MP14 15 29 9 1 P1  W= 0.45U L= 0.05U
MP15 16 32 15 1 P1  W= 0.45U L= 0.05U
MP16 1 34 16 1 P1  W= 0.45U L= 0.05U
MP17 18 30 1 1 P1  W= 0.10U L= 0.05U
MP18 1 29 17 1 P1  W= 0.10U L= 0.05U
MP19 1 29 18 1 P1  W= 0.10U L= 0.05U
MP20 1 32 19 1 P1  W= 0.10U L= 0.05U
MP21 18 32 1 1 P1  W= 0.10U L= 0.05U
MP22 1 34 20 1 P1  W= 0.10U L= 0.05U
MP23 1 34 18 1 P1  W= 0.10U L= 0.05U
*
C2 1 0  1.188fF
C3 1 0  0.528fF
C4 4 0  0.092fF
C5 5 0  0.308fF
C6 6 0  0.059fF
C7 7 0  0.086fF
C8 8 0  0.086fF
C9 9 0  0.376fF
C10 10 0  0.086fF
C11 11 0  0.086fF
C12 12 0  0.086fF
C13 13 0  0.086fF
C14 14 0  0.188fF
C15 15 0  0.086fF
C16 16 0  0.092fF
C17 17 0  0.202fF
C18 18 0  0.309fF
C19 19 0  0.216fF
C20 20 0  0.223fF
C22 22 0  0.281fF
C23 23 0  0.083fF
C24 24 0  0.276fF
C25 25 0  0.273fF
C26 26 0  0.130fF
C27 27 0  0.136fF
C28 28 0  0.136fF
C29 29 0  0.282fF
C30 30 0  0.059fF
C31 31 0  0.001fF
C32 32 0  0.259fF
C33 33 0  0.001fF
C34 34 0  0.249fF
C35 35 0  0.001fF
C36 36 0  0.001fF
C37 37 0  0.001fF
C38 38 0  0.001fF
C39 39 0  0.001fF
C40 40 0  0.001fF
C41 41 0  0.001fF
C42 42 0  0.001fF
C43 43 0  0.001fF
C44 44 0  0.001fF
C45 45 0  0.001fF
C46 46 0  0.001fF
C47 47 0  0.001fF
C48 48 0  0.001fF
C49 49 0  0.001fF
C50 50 0  0.001fF
C51 51 0  0.001fF
C52 52 0  0.001fF
C53 53 0  0.001fF
C54 54 0  0.001fF
C55 55 0  0.001fF
C56 56 0  0.001fF
C57 57 0  0.001fF
C58 58 0  0.001fF
C59 59 0  0.001fF
*
* n-MOS Model 3 :
* low leakage
.MODEL N1 NMOS LEVEL=3 VTO=0.40 UO=600.000 TOX= 2.0E-9
+LD =0.000U THETA=0.500 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=120.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* p-MOS Model 3:
* low leakage
.MODEL P1 PMOS LEVEL=3 VTO=-0.45 UO=200.000 TOX= 2.0E-9
+LD =0.000U THETA=0.300 GAMMA=0.400
+PHI=0.200 KAPPA=0.060 VMAX=110.00K
+CGSO=100.0p CGDO=100.0p
+CGBO= 60.0p CJSW=240.0p
*
* Transient analysis
*
* (Winspice)
.options temp=27.0
.control
tran 0.1N 50.00N
print  V(14) V(20) V(4) V(9) V(17) V(32) V(34) V(29) V(30) > out.txt
plot  V(14) V(20) V(4) V(9) V(17) V(32) V(34) V(29) V(30)
.endc
.END
